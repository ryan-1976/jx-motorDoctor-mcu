# Keil uVision project jx-motorDt-stm32L151.uvproj, settings and files
target jx-motorDt-stm32L151 (ARM-ADS)
  device: STM32L151RC STMicroelectronics
  cpu: IRAM(0x20000000-0x20007FFF) IROM(0x8000000-0x803FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: jx-motorDt-stm32L151
  c flags: Optim=4 OneElfS=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32L151xC
  c misc: --C99
  c include: ../Inc;../Drivers/STM32L1xx_HAL_Driver/Inc;../Drivers/STM32L1xx_HAL_Driver/Inc/Legacy;../Drivers/CMSIS/Device/ST/STM32L1xx/Include;../Drivers/CMSIS/Include
  library: MicroLIB
  link misc: --diag_suppress=L6329
  group Application/MDK-ARM
    ./: startup_stm32l151xc.s
  group Drivers/STM32L1xx_HAL_Driver
    ../Drivers/STM32L1xx_HAL_Driver/Src/: stm32l1xx_hal_tim_ex.c stm32l1xx_hal_dma.c stm32l1xx_hal_uart.c stm32l1xx_hal_flash.c stm32l1xx_hal_rcc.c stm32l1xx_hal_pwr.c stm32l1xx_hal_cortex.c stm32l1xx_hal_flash_ex.c stm32l1xx_hal_spi_ex.c stm32l1xx_hal_flash_ramfunc.c stm32l1xx_hal_pwr_ex.c stm32l1xx_hal_adc.c stm32l1xx_hal.c stm32l1xx_hal_rcc_ex.c stm32l1xx_hal_adc_ex.c stm32l1xx_hal_wwdg.c stm32l1xx_hal_gpio.c stm32l1xx_hal_tim.c stm32l1xx_hal_spi.c
  group Drivers/CMSIS
    ../Src/: system_stm32l1xx.c
  group Application/User
    ../Src/: main.c stm32l1xx_it.c stm32l1xx_hal_msp.c
